Commit message: single rigid body simulation

File: urdf_parser/singleton.urdf (robot description, URDF)
Before this commit: robot Singleton, 1 links, 0 joints
Links:
- link link: mass 1 -> 10
